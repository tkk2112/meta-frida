# Frida components may be built for the target, build host, and SDK host.
BBCLASSEXTEND = "native nativesdk"
